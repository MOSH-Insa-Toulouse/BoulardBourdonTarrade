# Repository MOSH-Insa-Toulouse/BoulardBourdonTarrade

File README.md:

# Projet Capteur  

This project is a Master's degree project at INSA - Toulouse.

  - [Installation](#installation)
  - [Usage](#usage)
  - [Arduino Code](#arduino-code)
  - [Shield](#shield)
  - [APK](#apk)
  - [Datasheet](#datasheet)
  - [Credits](#credits)
  - [Roadmap](#roadmap)

## Installation

  * Use the Gerber folder to create the Arduino Shield.  
  * Once created, use the datasheet schematics to solder all the components onto the shield.  
  * When the shield is completed, plug it onto an Arduino Uno.  
  * Transfer the program, found in Project in the master level, into the Arduino.
  * You are then good to go! You can now start measuring different electrical resistances with your sensor. 
  * In addition to displaying the datas onto the OLED screen, you can also choose to display them on the Serial Plotter of the Arduino, or you can download our mobile    phone app (see section APK). 

## Usage

The Arduino Uno is able to measure the tension and the resistance of your sensor as is. 

However, if you want to measure the deflection of the sensor, you will need to use the 2 points calibration menu, named "Etalon 2 points". 
First, simply straighten the sensor and press the rotary encoder once. This will calibrate the resistance at the sensor's rest position (R0). 
Afterwards, rotate the same encoder to a chosen angle of deflection, before applying said angle onto the sensor. Once applied, press the encoder once. Repeat this step and press the encoder again to finalise the calibration. 

After completing the calibration, all calibration values (R0, slope and offset) can be found in the menu entitled "Menu Calibration".

## Arduino Code

The full Arduino code is available in the GitHub "Projet" folder, it is entirely commented and can be modified at will.

## Shield

All the details related to the shield are available in the "Shield Uno" and the "Gerber" folders, which can be modified at will by using the electronic design automation software called KiCad.

## APK

The mobile application, defined by its extension .apk, was created using the tools on MIT's AppInventor website. If necessary, the application can be modified using this same tool. However, to do so, you will need the .aia file used to create the application. Both the .apk and .aia files can be found in the Master level of the GitHub.

## Datasheet

All the details concerning the sensor is available in our datasheet, which is composed of a primary pdf file and a complementary Excel sheet (.xlsx).

## Created by

BOULARD Tanguy  
BOURDON Léo  
TARRADE Manon  

## Roadmap

  - [x] Build the shield
  - [x] Program a first version of the Arduino Code
  - [x] Create the mobile application which displays and saves the datas measured by the sensor
  - [x] Create the datasheet of the sensor
  - [x] Add a 2 points calibration menu in the Arduino Code
  - [ ] Add a Test Bench menu on the Arduino
  - [ ] Make the sensor more reliable

## KiCad design Shield Uno/Shield Uno.kicad_pcb

Parts:
C1, C2, C3: 100n; C_Rect_L4.0mm_W2.5mm_P2.50mm
C4: 1µ; C_Rect_L7.0mm_W4.5mm_P5.00mm
P1: Power; Socket_Strip_Arduino_1x08
P2: Analog; Socket_Strip_Arduino_1x06
P3: Digital; Socket_Strip_Arduino_1x10
P4: Digital; Socket_Strip_Arduino_1x08
P5, P6, P7, P8: CONN_01X01; Arduino_1pin
R0: Rsensor
R1, R3: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R6: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
U1: ltc1050
U2: HC05
U3: OLED0.91; OLED
U4: EncodeurRotatoir; RotoEncodeur

Connections:
+5V: C3.1, P1.5, R0.1, U1.7, U2.1 (VCC), U3.3, U4.4 (VCC)
/3.5V: P1.4
/IOREF: P1.2
/Reset: P1.3
/Vin: P1.8
ADC: C2.1, P2.1, R6.1
CLK: P4.6, U4.1 (CLK)
DATA: P3.8, U4.2 (DATA)
GND: C1.2, C2.2, C3.2, P1.6, P1.7, P3.4, R1.1, R2.1, U1.4, U2.2 (GND), U3.4, U4.5 (GND)
IN+: C1.1, R1.2, R5.2, U1.3
IN-: C4.2, R2.2, R3.1, U1.2
unnamed: C4.1, R3.2, R6.2, U1.6
unnamed: R0.2, R5.1
RX: P3.5, U2.3 (TX_to_RX)
SCL: P3.1, U3.2
SDA: P3.2, U3.1
SWITCH: P3.7, U4.3 (SWITCH)
TX: P3.6, U2.4 (RX_to_TX)

Notes on the sheet:
Holes
Shield for Arduino that uses the same pin disposition like "Uno" board Rev 3.
Modules
Circuit Transimpé

Board: 2 copper layers, 68.6 x 53.3 mm, 22 parts (0 on the bottom side), 14 nets.

## Commit log

2021-03-19 version initiale du projet
2021-03-19 Version 1.1
2021-03-19 Version 1.2
2021-03-19 Version 1.3
2021-03-19 Version 1.4
2021-03-19 Version 1.5
2021-03-19 Version 1.6
2021-03-26 Version 1.7
2021-03-26 Version 1.8
2021-03-26 Version 1.9
2021-03-26 Version 2.0
2021-03-26 Version 2.1
